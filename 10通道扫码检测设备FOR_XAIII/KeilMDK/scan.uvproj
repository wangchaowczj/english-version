# Keil uVision project scan.uvproj, settings and files
target scan (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CPU +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,__FPU_USED
  c include: ..\CMSIS;..\FatFs\src;..\FatFs\src\option;..\STemWinDlg;..\STemWinLibrary522\Config;..\STemWinLibrary522\inc;..\STemWinLibrary522\Lib;..\STemWinLibrary522\OS;..\STM32F4xx_StdPeriph_Driver\inc;..\UCOSII\Config;..\UCOSII\Ports;..\UCOSII\Source;..\User;..\CH374
  memory RVCT4: ROM 0x8010000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../User/: Main.c
  group User
    ../User/: stm32f4xx_it.c SystemConfig.c TaskUtils.c GuestRespond.c Task.c Recorder.c MidFunction.c DetTest.c XA2_DetTest.c GuestRespondForFactory34.c GuestRespondForFactory10.c GuestRespondForFactory52.c
  group StemWindDlg
    ../STemWinDlg/: GuiIncludes.h GuiCustomUtils.c CustomMessageBox.c StatusBar.c DeskMenu.c PowerOff.c DeviceStart.c MainMenu.c ChannelTestPrepareFigure.c ChannelStatusFigure.c 1ChannelTestPrepare.c 1ChannelTestResult.c DetTestErrorList.c SystemTool.c DetAnalyst.c DetAnalystResult.c SelfTest.c DeviceDemarcateMenu.c DeviceDemarcate.c HexFileImport.c ScanTest.c SystemSet.c StageSet.c DetTestContentMenu.c DetTestCurrentContent.c DetTestContentModify.c DetTestParamPwd.c DetTestParamStageMenu.c DetTestParamMenu.c DetTestParamCurrentSet.c DetTestParamFreqSet.c DetTestParamMaskBitSet.c SoundSet.c LcdBrightSet.c RtcSet.c DeviceInfo.c DeviceInfoMenu.c DetTestRecorderList.c WaitDiskInsert.c FileExportToMsc.c DetTestContentEnterFactorySetDlg.c TestItemAndCodingSetDlg.c NetModeSetDlg.c ChannelCountSetDlg.c AutoBackSet.c
  group User_Driver
    ../User/: adc.c aes.c AnsiToUnicode.c BarCode.c CRC16.c Delay.c DetHardware.c FSMC.c RA8875.c rtc.c slip.c Sound.c keyScan.c Power.c Sleep.c SdCard.c Package.c Battery.c Usarts.c CRC8.c CRC32.c DetInfoQueue.c DetOutsideCodeQueue.c XA2_DetCmd.c
  group CH374
    ../CH374/: CH374Device.c CH374DeviceHid.c CH374DeviceMsc.c CH374Host.c CH374HostHid.c CH374HostMsc.c CH374Interface.c CH374Process.c
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group uCOSII-Config
    ../UCOSII/Config/: app_cfg.h os_cfg.h os_includes.h
  group uCOSII-Ports
    ../UCOSII/Ports/: os_cpu_a.asm os_cpu_c.c
  group uCOSII-Source
    ../UCOSII/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.c
  group FatFs
    ../FatFs/src/: diskio.c ff.c
    ../FatFs/src/option/: cc936.c
  group STemWinLib
    ../STemWinLibrary522/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../STemWinLibrary522/Lib/: STemWin522_CM4_OS_Keil.lib
    ../STemWinLibrary522/OS/: GUI_X_UCOSII.c
  group Font
    ../Font/: SongTi24.c
  group Icon
    ../Icon/: Scan.c USBErrorIcon.c USBIcon.c USBNonSupportIcon.c DiskIcon.c
  group doc
    ../Doc/: History.txt
