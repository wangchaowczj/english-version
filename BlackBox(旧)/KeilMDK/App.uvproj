# Keil uVision project App.uvproj, settings and files
target App (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: App +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,__FPU_USED
  c include: ..\CMSIS;..\FatFs\src;..\FatFs\src\option;..\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4xx_StdPeriph_Driver\src;..\User;..\UCOSII\Config;..\UCOSII\Ports;..\FatFs\src;..\FatFs\src;..\USB;..\USB\usb_device\class\src;..\USB\usb_device\class\inc;..\USB\usb_driver\inc;..\USB\usb_driver\src;..\USB\usb_host\class\inc;..\USB\usb_host\class\src;..\USB\usb_host\core\inc;..\USB\usb_host\core\src;..\USB\user_usb\inc;..\USB\user_usb\src;..\USB\usb_device\core\inc;..\USB\usb_device\core\src;..\UCOSII\Source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../User/: Main.c
  group User
    ../User/: stm32f4xx_it.c SystemConfig.c TaskUtils.c Task.c GuestRespond.c Utils.c Recorder.c
  group User_Driver
    ../User/: adc.c rtc.c SdCard.c Power.c aes.c slip.c Package.c CRC16.c Delay.c DetTransceiver.c MsgQeue.c
    ../USB/: usb.c
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_pwr.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group uCOSII-Config
    ../UCOSII/Config/: app_cfg.h os_cfg.h os_includes.h
  group uCOSII-Ports
    ../UCOSII/Ports/: os_cpu_c.c os_cpu_a.asm
  group uCOSII-Source
    ../UCOSII/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group FatFs
    ../FatFs/src/: diskio.c ff.c
    ../FatFs/src/option/: cc936.c
  group usb_device
    ../USB/usb_device/class/src/: usbd_hid_core.c usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ../USB/usb_device/core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usb_driver
    ../USB/usb_driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group usb_host
    ../USB/usb_host/class/src/: usbh_hid_core.c usbh_hid_custom.c
    ../USB/usb_host/core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group user_usb
    ../USB/user_usb/src/: usb_bsp.c usbd_hid_desc.c usbd_msc_desc.c usbd_storage_msd.c usbd_usr.c usbh_usr.c
  group Doc
    ../Doc/: History.txt
