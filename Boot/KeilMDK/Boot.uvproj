# Keil uVision project Boot.uvproj, settings and files
target Boot (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Boot +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,__FPU_USED,USE_USB_OTG_FS
  c include: ..\CMSIS;..\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4xx_StdPeriph_Driver\src;..\User;..\USB\STM32_USB_Device_Library\Class\msc\inc;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\USB_APP;..\FatFs\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../User/: Main.c
  group User
    ../User/: stm32f4xx_it.c SystemConfig.c AppUpdate.c
  group Driver
    ../User/: Delay.c Power.c SdCard.c slip.c CRC16.c i2c.c Lcd.c LcdUtils.c
  group CMSIS
    ../CMSIS/: startup_stm32f40xx.s system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group FatFs
    ../FatFs/src/: diskio.c ff.c
  group Doc
    ../Doc/: History.txt
