# Keil uVision project App.uvproj, settings and files
target App (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CPU +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,__FPU_USED
  c include: ..\CMSIS;..\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4xx_StdPeriph_Driver\src;..\User;..\FatFs\src;..\USB\usb_device\core\inc;..\USB\usb_device\class\inc;..\USB\usb_driver\inc;..\USB\usb_host\class\inc;..\USB\usb_host\core\inc;..\USB\user_usb\inc;..\USB
  memory RVCT4: ROM 0x8010000 size 0xb0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../User/: Main.c
  group User
    ../User/: stm32f4xx_it.c GuestRespond.c SystemConfig.c Recorder.c Utils.c Task.c XA3F_DetTest.c
  group Driver
    ../User/: adc.c CRC16.c Delay.c Power.c Machine.c Event.c DetHardware.c DetTestComm.c XA3F_DetCmd.c RS485.c aes.c slip.c Package.c Key.c SdCard.c Lcd.c LcdUtils.c i2c.c
    ../USB/: usb.c
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40xx.s
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_pwr.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_tim.c
  group FatFs
    ../FatFs/src/: ff.c diskio.c
    ../FatFs/src/option/: cc936.c
  group usb_device
    ../USB/usb_device/core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/usb_device/class/src/: usbd_hid_core.c usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group usb_driver
    ../USB/usb_driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group usb_host
    ../USB/usb_host/core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/usb_host/class/src/: usbh_hid_core.c usbh_hid_custom.c
  group user_usb
    ../USB/user_usb/src/: usb_bsp.c usbd_hid_desc.c usbd_msc_desc.c usbd_storage_msd.c usbd_usr.c usbh_usr.c
  group Doc
    ../Doc/: History.txt
