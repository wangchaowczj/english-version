# Keil uVision project ucosii.uvproj, settings and files
target UCOSII (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ucosii +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\STM32F10x_StdPeriph_Driver\inc;..\uCOS-II\Ports;..\uCOS-II\Source;..\USER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group USER
    ../USER/: main.c stm32f10x_it.c SystemConfig.c Task.c
  group DRIVER
    ../USER/: Delay.c i2c.c Lcd.c LcdUtils.c LED.c GET_USB.c
  group UCOSII-PORT
    ../uCOS-II/Ports/: app_cfg.h os_cpu_c.c os_dbg.c os_cpu_a.asm
  group UCOSII-SOURCE
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.c
  group FWLIB
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c
  group doc
    ../doc/: readme.txt
