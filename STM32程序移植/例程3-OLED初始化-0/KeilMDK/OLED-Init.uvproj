# Keil uVision project OLED-Init.uvproj, settings and files
target OLED (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OLED-Init +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\SYSTEM\usart;..\USER\I2C;..\USER\LCD;..\USER;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../USER/: stm32f10x_conf.h stm32f10x_it.c main.c
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group SYSTEM
    ../SYSTEM/: Delay.c
  group DRIVER
    ../USER/I2C/: i2c.c
    ../USER/LCD/: Lcd.c LcdUtils.c
