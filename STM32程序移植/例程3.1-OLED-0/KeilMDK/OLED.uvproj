# Keil uVision project OLED.uvproj, settings and files
target OLED (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OLED
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\USER\IIC;..\USER\OLED;..\USER\LED
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c
  group USER
    ../USER/: stm32f10x_it.c main.c
  group DRIVER
    ../USER/IIC/: myiic.c
    ../USER/LED/: led.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c
