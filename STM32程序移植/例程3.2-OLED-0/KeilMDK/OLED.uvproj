# Keil uVision project OLED.uvproj, settings and files
target OLED (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OLED
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\STM32F10x_FWLib\inc;..\SYSTEM;..\USER;..\USER\I2C;..\USER\LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group USER
    ../USER/: stm32f10x_it.c SystemConfig.c main.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group DRIVER
    ../USER/I2C/: i2c.c
    ../USER/LCD/: Lcd.c LcdUtils.c
  group SYSTEM
    ../SYSTEM/: Delay.c
