# Keil uVision project ADC.uvproj, settings and files
target ADC (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ADC +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLIB\inc;..\SYSTEM;..\USER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group USER
    ../CMSIS/: SystemConfig.c
    ../USER/: main.c stm32f10x_it.c
  group DRIVER
    ../USER/: i2c.c Lcd.c LcdUtils.c LED.c AD.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group SYSTEM
    ../SYSTEM/: Delay.c
