# Keil uVision project USB_Test.uvproj, settings and files
target USB (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USB_Test +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLIB\inc;..\USER;..\CH374
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group MAIN
    ../USER/: main.c
  group USER
    ../USER/: stm32f10x_it.c SystemConfig.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_gpio.c
  group DRIVER
    ../USER/: Delay.c i2c.c Lcd.c LcdUtils.c LED.c GET_USB.c aes.c CRC16.c GuestRespond.c Package.c slip.c
  group CH374
    ../CH374/: CH374Device.c CH374DeviceHid.c CH374DeviceMsc.c CH374Host.c CH374HostHid.c CH374HostMsc.c CH374Interface.c CH374Process.c
