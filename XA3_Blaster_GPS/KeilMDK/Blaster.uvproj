# Keil uVision project Blaster.uvproj, settings and files
target Blaster (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CPU +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,__FPU_USED
  c include: ..\CMSIS;..\FatFs\src;..\FatFs\src\option;..\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4xx_StdPeriph_Driver\src;..\User;..\UCOSII\Config;..\UCOSII\Ports;..\UserGUI;..\FatFs\src;..\FatFs\src;..\USB;..\USB\usb_device\class\src;..\USB\usb_device\class\inc;..\USB\usb_driver\inc;..\USB\usb_driver\src;..\USB\usb_host\class\inc;..\USB\usb_host\class\src;..\USB\usb_host\core\inc;..\USB\usb_host\core\src;..\USB\user_usb\inc;..\USB\user_usb\src;..\USB\usb_device\core\inc;..\USB\usb_device\core\src;..\UCOSII\Source;..\STemWinLibrary522\Config;..\STemWinLibrary522\inc;..\STemWinLibrary522\Lib;..\STemWinLibrary522\OS
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../User/: Main.c
  group User
    ../User/: stm32f4xx_it.c SystemConfig.c Task.c det_operart.c MidFunction.c Recorder.c SafeMonitor.c SoftwareUpdate.c GuestRespond.c MasterMode.c BlueDkey.c BlueMaster.c TaskUtils.c LogUpload.c
  group UserGUI
    ../UserGUI/: GuiIncludes.h Display.c GuiCustomUtils.c CustomMessageBox.c LoadingDlg.c TopTitleDlg.c MainMenuDlg.c MainMenuMoreDlg.c BlastEnterDlg.c NetInfoDlg.c WaitLinCurrentReadyDlg.c NetTestReportDlg.c NetTestErrorListViewDlg.c NetParamModifyDlg.c BlastTestReportDlg.c BlastProcessDlg.c DeleteDetMenuDlg.c DeleteDetInputHoleInfoDlg.c DelayModifyBatchDlg.c DelayModifySingleDlg.c InfoManageDlg.c DeviceInfoDlg.c BlastRecorderListViewDlg.c SystemSetMenuDlg.c SliderDlg.c BlastDelayDlg.c BlastDetDlg.c PowerOffDlg.c DeviceStartDlg.c DkeyPasswdModifyDlg.c HelpToolMenuDlg.c HelpToolDetTestDlg.c DetAnalystDlg.c WifiNetInfoDlg.c DeviceChargeStartDlg.c WifiNetInitDlg.c WifiPasswordDlg.c WifiNetSetDlg.c UploadBlastRecordDlg.c NetParamListViewDlg.c SoftwareUpdateDlg.c BlastInfoVerifyDlg.c DeviceSelfTestDlg.c DeviceUsagesSetDlg.c DeviceNameSetDlg.c RemoteBlastSlaveStateDlg.c SlaveNumberSetDlg.c SlaveInfoListViewDlg.c BlastMasterProcessDlg.c BlueHostStatusDlg.c DetBackupBlueTypeSelDlg.c DetBlueBackupMenuDlg.c SlaveStatusDlg.c DetSlaveBackupMenuDlg.c BlastRecorderDetailedDlg.c BlastRecorderDetInfoListDlg.c BlastRecorderMasterBriefDlg.c BlastRecorderSlaveInfoListDlg.c ProgbarBlastDlg.c ProgbarChargeDlg.c ProgbarCompleteDlg.c ProgbarQuickDlg.c ProgbarQuickBeforeBlastDlg.c ProgbarMaskRegDetDlg.c DelaySampleProcessDelaySelDlg.c DelaySampleProcessDelayInputDlg.c DelaySampleProcessWaitRegDetDlg.c DelaySampleProcessBlastDetDlg.c DelaySampleProcessReadyConfirmDlg.c DetBackupOperateTypeSelDlg.c DetBackupOperateBlueTypeSelDlg.c DetInfoInsertRangeInputDlg.c DetInfoInsertStatusDlg.c DetBlueInsertMenuDlg.c NetInfoModifyMenuDlg.c NetInfoModifyRangeInputDlg.c BusErrorRestoreDlg.c DetAnalystHighVoltageInputDlg.c DetAnalystBlastDlg.c DetCodeWriteMenuDlg.c DetCodeWriteStatusDlg.c WifiConnectDlg.c MasterBlastDelaySetDlg.c LogRecorderListViewDlg.c LogUploadDlg.c FileSystemFormatDlg.c BlastCannelDlg.c ColorSetDlg.c WaitRegListViewDlg.c RegParamMenuDlg.c RegHoleParamInputDlg.c RegHoleInsertInputDlg.c DetTypeSetDlg.c DetOutsideInputDlg.c RegDetOutsideInputBatchDlg.c RegDetFeatureInputForBarcodeDlg.c DetAccreditErrorForDLDlg.c SlaveAccreditErrorForDLDlg.c BlastTerminationFromAppDlg.c WaitPowerOffDlg.c MasterTimeShareSetDlg.c
  group User_Driver
    ../User/: Delay.c rtc.c Charge.c Power.c LcdSSD1963.c LcdDraw.c slip.c AnsiToUnicode.c adc.c SdCard.c CRC16.c keyScan.c sound.c Package.c aes.c Wifi.c Flash.c RS485.c Bluetooth.c DAC.c LTC2942.c I2C.c Scan.c DetHardware.c BarCode.c base64.c CRC8.c XA3_DetCmd.c gps.c
    ../USB/: usb.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_i2c.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_dac.c
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group uCOSII-Config
    ../UCOSII/Config/: app_cfg.h os_cfg.h os_includes.h
  group uCOSII-Ports
    ../UCOSII/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOSII-Source
    ../UCOSII/Source/: os_tmr.c os_time.c os_task.c os_sem.c os_q.c os_mutex.c os_mem.c os_mbox.c os_flag.c os_core.c
  group FatFs
    ../FatFs/src/: diskio.c ff.c
    ../FatFs/src/option/: cc936.c
  group usb_device
    ../USB/usb_device/core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/usb_device/class/src/: usbd_hid_core.c usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group usb_driver
    ../USB/usb_driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group usb_host
    ../USB/usb_host/class/src/: usbh_hid_core.c usbh_hid_custom.c
    ../USB/usb_host/core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group user_usb
    ../USB/user_usb/src/: usb_bsp.c usbd_hid_desc.c usbd_msc_desc.c usbd_storage_msd.c usbd_usr.c usbh_usr.c
  group STemWinLib
    ../STemWinLibrary522/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../STemWinLibrary522/OS/: GUI_X_UCOSII.c
    ../STemWinLibrary522/Lib/: STemWin522_CM4_OS_Keil.lib
  group Font
    ../Font/: SongTi16.c SongTi24.c SongTi48.c
  group Logo
    ../Logo/: Logo00.c Logo34.c
  group Doc
    ../Doc/: History.txt
