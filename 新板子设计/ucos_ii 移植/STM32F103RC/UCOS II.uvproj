# Keil uVision project UCOS II.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UCOS II
  c flags: Optim=1
  c include: .\UCOSII\CMSIS;.\UCOSII\CONFIG;.\UCOSII\CORE;.\UCOSII\PORT
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group UCOSII-PORT
    ./UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ./UCOSII/CONFIG/: includes.h os_cfg.h
  group UCOSII-CORE
    ./UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group CMSIS
    ./UCOSII/CMSIS/: startup_stm32f10x_hd.s system_stm32f10x.c system_stm32f10x.h
  group SYSTEM
    ./UCOSII/SYSTEM/: sys.c sys.h
    ./SYSTEM/: stm32f10x.h
  group USER
    ./USER/: stm32f10x_it.c stm32f10x_it.h main.c
